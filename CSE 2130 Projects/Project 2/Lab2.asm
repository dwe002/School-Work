.ORIG x3000
LDI R1, X
LDI R2, Y

;X-Y
NOT R4, R2
ADD R4, R4, #1
ADD R4, R1, R4
STI R4, x_2

;|X|
ADD R3, R1, #0
BRzp ZP1
NOT R3, R3
ADD R3, R3, #1
ZP1 STI R3, absX

;|Y|
ADD R4, R2, #0
BRzp ZP2
NOT R4, R4
ADD R4, R4, #1
ZP2 STI R4, absY

;|X|&|Y| GREATEST
NOT R5, R4
ADD R5, R5, #1
ADD R5, R3, R5

BRz ZERO
BRp ONE
ADD R5, R3, R5
ADD R5, R4, #0
BRn TWO
ADD R5, R3, R5
ADD R5, R4, #0

ZERO ADD R6, R6, #0
ONE ADD R5, R6, #1
TWO ADD R6, R6, #2
STI R6, Z

HALT
X .FILL X3120
Y .FILL X3121
X_2 .FILL X3122
absX .FILL X3123
absY .FILL X3124
Z .FILL X3125
.END

.ORIG X3120
.FILL #9
.FILL #-13
.END
